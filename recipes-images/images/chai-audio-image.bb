inherit chai-image

IMAGE_INSTALL_append = " \
    alsa-utils \
"
