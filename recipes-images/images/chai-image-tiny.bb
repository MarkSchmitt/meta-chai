inherit chai-image-tiny