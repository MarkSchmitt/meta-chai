inherit chai-image